options:
  parameters:
    generate_options: qt_gui
    id: prueba_barrido
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    start: '-11'
    step: '0.500'
    stop: '11'
    value: '1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 470e6
    step: 10e6
    stop: 710e6
    value: 660e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12500000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.000976562'
    type: complex
    vlen: vec_len
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: vec_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: float
    vlen: '1024'
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: float
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import csv
      from gnuradio import gr  # Importamos correctamente el módulo de GNU Radio

      class MyPythonSink(gr.sync_block):
          def __init__(self):
              # Inicializamos el bloque con una entrada que es un vector flotante
              gr.sync_block.__init__(self,
                  name="python_sink", 
                  in_sig=[np.float32],  # Aquí especificamos que los datos de entrada son vectores de tipo float32
                  out_sig=[])  # El bloque no tiene salida

          def work(self, input_items, output_items):
              # Obtener los datos de entrada, que es un vector de floats (por ejemplo, de tamaño 1024)
              data = input_items[0]
              
              # Convertir los datos a un array numpy (si es necesario)
              data_to_save = np.array(data)
              
              # Guardar los datos en formato CSV (modo append para agregar nuevos datos)
              with open('output_data.csv', mode='a') as file:
                  writer = csv.writer(file)
                  writer.writerow(data_to_save)  # Guardamos el vector completo como una fila en el CSV
              
              return len(input_items[0])  # Devuelve el número de muestras procesadas
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import csv\nfrom gnuradio import gr\nimport numpy as np\n\nclass RealtimeCsvSink(gr.sync_block):\n    def __init__(self, filename='output.csv'):\n        gr.sync_block.__init__(\n            self,\n            name=\"RealtimeCsvSink\",\n            in_sig=[np.float32],  # Si tus datos son vectores de tipo float32\n            out_sig=None\n        )\n        self.f = open(filename, 'w', newline='')\n        self.writer = csv.writer(self.f)\n        self.writer.writerow([f'Sample_{i}' for i in range(1024)])  # Escribir encabezado (muestras 0 a 1023)\n    \n    def work(self, input_items, output_items):\n        # input_items[0] es el vector que recibimos de tamaño 1024\n        for i in range(len(input_items[0])):\n            # Escribe cada valor del vector en una fila del archivo CSV\n            self.writer.writerow(input_items[0][i])\n        \n        return len(input_items[0])\n    \n    def stop(self):\n        self.f.close()\n        return True\n\n"
    filename: '''output.csv'''
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: filerepeater_VectorToTxtFile_1
  id: filerepeater_VectorToTxtFile
  parameters:
    WriteTimeHeader: 'True'
    append: 'True'
    filename: C:\Users\Paula\Downloads\pruebaHackRF.csv
    frequency: freq
    notes: ''
    precision: '2'
    sampleRate: samp_rate
    updateRateSec: '30.0'
    vectorsize: vec_len
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
    ymin: '-250'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: vec_len
    x_start: '0'
    x_step: '1.0'
    ymin: '-200'
  states: {}
- name: skip4
  id: blocks_skiphead
  parameters:
    num_items: '1'
    type: float
    vlen: '1024'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_nlog10_ff_0, '0', epy_block_0, '0']
- [blocks_nlog10_ff_0, '0', filerepeater_VectorToTxtFile_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0, '0', skip4, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', epy_block_1, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [osmosdr_source_0, '0', blocks_throttle2_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [skip4, '0', blocks_vector_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
