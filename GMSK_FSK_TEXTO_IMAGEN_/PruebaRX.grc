options:
  parameters:
    generate_options: qt_gui
    id: GMSK
    output_language: python
    title: GMSK_RX
  states: {}

blocks:
- name: BT
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: BT
    start: '0.0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 437e6
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Frecuencia centro
    start: '470'
    step: '0.05'
    stop: '698'
    value: '470'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    start: '0'
    step: '0.01'
    stop: '40'
    value: '31.5'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '12500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '10000'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-140'
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Canal
    label1: Rx
    num_tabs: '2'
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
    sensitivity: np.pi/sps
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr

      class image_receiver(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='image_receiver',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              self.receiving = False
              self.received = bytearray()

          def handle_msg(self, msg):
              vec = pmt.cdr(msg)
              data = bytearray(pmt.u8vector_elements(vec))

              if data == b"START":
                  self.receiving = True
                  self.received = bytearray()
                  print("[RX] Recibiendo imagen...")

              elif data == b"END":
                  if self.receiving:
                      with open("/home/estudiante/Descargas/imagen_recibida.jpg", "wb") as f:
                          f.write(self.received)
                      print(f"[RX] Imagen reconstruida correctamente. Total: {len(self.received)} bytes")
                      self.receiving = False
                  else:
                      print("[RX] END recibido sin START")

              elif self.receiving:
                  self.received += data
                  print(f"[RX] Chunk recibido: {len(data)} bytes")
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Hex to ASCII",
                  in_sig=[],
                  out_sig=[])
              self.message_port_register_in(gr.pmt.intern("in"))
              self.message_port_register_out(gr.pmt.intern("out"))
              self.set_msg_handler(gr.pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg_pmt):
              # Extraer los datos del mensaje
              if gr.pmt.is_pair(msg_pmt):
                  msg = gr.pmt.cdr(msg_pmt)
              else:
                  msg = msg_pmt

              if gr.pmt.is_u8vector(msg):
                  byte_array = bytes(bytearray(gr.pmt.u8vector_elements(msg)))
                  try:
                      ascii_text = byte_array.decode('ascii', errors='replace')
                      print("\n🟢 Texto ASCII recibido:\n", ascii_text)
                  except Exception as e:
                      print("❌ Error al decodificar:", e)

              # Reenvía el mensaje (si deseas conservar el flujo)
              self.message_port_pub(gr.pmt.intern("out"), msg_pmt)
  states: {state: disabled}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.8*(samp_rate/sps)
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.2*(samp_rate/sps)
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: 2240E6
    fftsize: '1024'
    gui_hint: 3,1,1,1
    label1: BT = 0.3
    name: '"Espectro RX"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,1
    label1: Rx Bits
    name: ''
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'transmited@1: 0,0,1,1'
    label1: Phase I
    label2: Quadrature Q
    name: ''
    size: '500'
    srate: samp_rate
    type: complex
    ymax: '4'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '8192'
    type: complex
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,1,1,1
    label0: Constelacion Rx
    num_tabs: '1'
  states: {state: disabled}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {state: disabled}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: 437e6
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: if_gain
  states: {state: disabled}
- name: transmited
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation Tx
    label1: Envolvente compleja Post Canal
    num_tabs: '2'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq*1e6
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc3_xx_0, '0', low_pass_filter_0_0, '0']
- [analog_simple_squelch_cc_0, '0', digital_gfsk_demod_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_descrambler_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_descrambler_bb_0, '0', satellites_hdlc_deframer_0, '0']
- [digital_gfsk_demod_0, '0', satellites_nrzi_decode_0, '0']
- [epy_block_0_0, out, blocks_message_debug_0, print]
- [low_pass_filter_0_0, '0', analog_simple_squelch_cc_0, '0']
- [satellites_hdlc_deframer_0, out, epy_block_0, msg_in]
- [satellites_hdlc_deframer_0, out, epy_block_0_0, in]
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [soapy_hackrf_source_0, '0', analog_agc3_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc3_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_1, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
