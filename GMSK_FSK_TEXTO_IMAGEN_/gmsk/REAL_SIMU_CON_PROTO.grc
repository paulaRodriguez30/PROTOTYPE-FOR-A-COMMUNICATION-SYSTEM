options:
  parameters:
    generate_options: qt_gui
    id: FULL_SIM_GMSK_v2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BT
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: BT
    start: '0.0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: bps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '18'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: formats
  id: variable
  parameters:
    value: digital.header_format_counter('10101010111101010101',thresh,bps)
  states: {state: disabled}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.005'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.14'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '100000'
    step: '1000000'
    stop: '20000000'
    value: '250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '3'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.1'
    value: '1.00'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '10000'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/radiogis/Documents/datos_gmskl.txt
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.make_u8vector(10, 0))
    period: '30'
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '100'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Canal
    label1: Rx
    num_tabs: '2'
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.25'
    mu: '0.5'
    omega_relative_limit: '0.02'
    samples_per_symbol: '4'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '4'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: formats
  states: {state: disabled}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pylab
      from gnuradio import gr
      import pmt


      class msg_block(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """This block converts strings from the QT GUI Message Edit Box to uint8 vectors"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
          
          def handle_msg(self, msg):
              nvec = pmt.to_python(msg)
              self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(np.array([ord(c) for c in nvec], np.uint8))))
          
          def work(self, input_items, output_items):
              pass
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr

      class image_sender(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='image_sender',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('msg_out'))

              with open("/home/estudiante/Descargas/a.jpg", "rb") as f:
                  self.image_data = f.read()

              self.chunks = [self.image_data[i:i+256] for i in range(0, len(self.image_data), 256)]

          def send_chunk(self, data):
              vec = pmt.init_u8vector(len(data), list(data))
              meta = pmt.make_dict()
              pdu = pmt.cons(meta, vec)
              self.message_port_pub(pmt.intern("msg_out"), pdu)

          def start(self):
              # Enviar señal de inicio
              self.send_chunk(b"START")
              print("[TX] Enviando encabezado START")

              # Enviar imagen por chunks
              for chunk in self.chunks:
                  self.send_chunk(chunk)
                  print(f"[TX] Enviando chunk: {len(chunk)} bytes")

              # Enviar señal de fin
              self.send_chunk(b"END")
              print("[TX] Enviando final END")
              return True
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr

      class image_sender(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='image_sender',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('msg_out'))

              # Leer imagen una vez
              with open("/home/estudiante/Descargas/imagen_prueba-128x128.jpg", "rb") as f:
                  self.image_data = f.read()

              # Dividir en chunks de 256 bytes
              self.chunks = [self.image_data[i:i+256] for i in range(0, len(self.image_data), 256)]

          def start(self):
              for i, chunk in enumerate(self.chunks):
                  vec = pmt.init_u8vector(len(chunk), list(chunk))  # 🔁 list() convierte los bytes a enteros
                  meta = pmt.make_dict()
                  pdu = pmt.cons(meta, vec)
                  print(f"[TX] Enviando chunk: {len(chunk)} bytes")
                  self.message_port_pub(pmt.intern("msg_out"), pdu)
              print("[TX] Transmisión completa.")
              return True
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr

      class image_receiver(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='image_receiver',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

              self.receiving = False
              self.received = bytearray()

          def handle_msg(self, msg):
              vec = pmt.cdr(msg)
              data = bytearray(pmt.u8vector_elements(vec))

              if data == b"START":
                  self.receiving = True
                  self.received = bytearray()
                  print("[RX] Recibiendo imagen...")

              elif data == b"END":
                  if self.receiving:
                      with open("/home/estudiante/Descargas/imagen_recibida.jpg", "wb") as f:
                          f.write(self.received)
                      print(f"[RX] Imagen reconstruida correctamente. Total: {len(self.received)} bytes")
                      self.receiving = False
                  else:
                      print("[RX] END recibido sin START")

              elif self.receiving:
                  self.received += data
                  print(f"[RX] Chunk recibido: {len(data)} bytes")
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate / (2 * 4)
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: (samp_rate / (2 * 4))/ 2
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Paquetes
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Señal Modulada
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Canal
  states: {}
- name: note_1
  id: note
  parameters:
    note: Visualizacion
  states: {state: disabled}
- name: note_2
  id: note
  parameters:
    note: delay=18
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'transmited@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,1,1,1
    is_pair: 'False'
    type: string
    value: '"Este es un mensaje de prueba con GMSK"'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,1,1,1
    label1: BT = 0.5
    name: '"Espectro RX"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,1
    label1: Rx Bits
    label2: Tx Bits
    name: '"Bits TX vs Bits RX"'
    nconnections: '2'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'transmited@1: 0,0,1,1'
    label1: Phase I
    label2: Quadrature Q
    name: ''
    size: '500'
    srate: samp_rate
    type: complex
    ymax: '4'
  states: {state: disabled}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,1,1,1
    label0: Constelacion Rx
    num_tabs: '1'
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_hdlc_framer_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '14'
    preamble_bytes: '100'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: transmited
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation Tx
    label1: Envolvente compleja Post Canal
    num_tabs: '2'
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: mensaje
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Señal_TX
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Salida_Canal
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: Bites_TX
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mensaje
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Señal_TX
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Salida_Canal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Bites_TX
  states: {state: disabled}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: Salida_Canal
  states: {state: disabled}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: Salida_Canal
  states: {state: disabled}
- name: virtual_source_4_0_0
  id: virtual_source
  parameters:
    stream_id: Señal_TX
  states: {state: disabled}

connections:
- [analog_agc3_xx_0, '0', low_pass_filter_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_message_strobe_0, strobe, digital_protocol_formatter_async_0, in]
- [blocks_message_strobe_0_0, strobe, epy_block_0, msg_in]
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [channels_channel_model_0, '0', virtual_sink_1_0, '0']
- [digital_descrambler_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_descrambler_bb_0, '0', satellites_hdlc_deframer_0, '0']
- [digital_gmsk_demod_0, '0', satellites_nrzi_decode_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_protocol_formatter_async_0, header, blocks_message_strobe_0, set_msg]
- [digital_scrambler_bb_0, '0', satellites_nrzi_encode_0, '0']
- [epy_block_0, msg_out, satellites_hdlc_framer_0_0, in]
- [epy_block_1, msg_out, satellites_hdlc_framer_0_0, in]
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', digital_scrambler_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_3, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_file_sink_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_message_strobe_0_0, set_msg]
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print]
- [satellites_hdlc_deframer_0, out, epy_block_3, msg_in]
- [satellites_hdlc_framer_0_0, out, blocks_message_debug_1, print]
- [satellites_hdlc_framer_0_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [satellites_nrzi_encode_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [virtual_source_0, '0', digital_gmsk_mod_0, '0']
- [virtual_source_1, '0', channels_channel_model_0, '0']
- [virtual_source_1_0, '0', analog_agc3_xx_0, '0']
- [virtual_source_2, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_3, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_0_1, '0']
- [virtual_source_4_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [virtual_source_4_0_0, '0', qtgui_const_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
