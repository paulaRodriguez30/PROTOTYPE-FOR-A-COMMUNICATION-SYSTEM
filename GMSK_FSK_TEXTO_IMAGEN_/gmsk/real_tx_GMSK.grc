options:
  parameters:
    generate_options: qt_gui
    id: Simulacion_V1
    output_language: python
    title: 'Transmisor GMSK '
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    start: 75e6
    step: '10'
    stop: 1000e6
    value: 437e6
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    start: 1e6
    step: '10'
    stop: 3000e6
    value: 437e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    start: '1'
    step: '1'
    stop: '45'
    value: '42'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    rangeType: int
    start: '100000'
    step: '1000000'
    stop: '20000000'
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/carlos/Escritorio/PRUEBAS /SIMULACIONES/simulacion_Full/FUNCIONAL 100%/archivotxtMIX
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '100'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: ''
    num_tabs: '1'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: excess_bw
    samples_per_symbol: '4'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_scrambler_bb_0_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr

      class image_sender(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='image_sender',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('msg_out'))

              with open("/home/estudiante/Descargas/a.jpg", "rb") as f:
                  self.image_data = f.read()

              self.chunks = [self.image_data[i:i+256] for i in range(0, len(self.image_data), 256)]

          def send_chunk(self, data):
              vec = pmt.init_u8vector(len(data), list(data))
              meta = pmt.make_dict()
              pdu = pmt.cons(meta, vec)
              self.message_port_pub(pmt.intern("msg_out"), pdu)

          def start(self):
              # Enviar señal de inicio
              self.send_chunk(b"START")
              print("[TX] Enviando encabezado START")

              # Enviar imagen por chunks
              for chunk in self.chunks:
                  self.send_chunk(chunk)
                  print(f"[TX] Enviando chunk: {len(chunk)} bytes")

              # Enviar señal de fin
              self.send_chunk(b"END")
              print("[TX] Enviando final END")
              return True
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pylab
      from gnuradio import gr
      import pmt


      class msg_block(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """This block converts strings from the QT GUI Message Edit Box to uint8 vectors"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
          
          def handle_msg(self, msg):
              nvec = pmt.to_python(msg)
              self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(np.array([ord(c) for c in nvec], np.uint8))))
          
          def work(self, input_items, output_items):
              pass
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: osmosdr_sink_1
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,0,1,2
    is_pair: 'False'
    type: string
    value: vamos a intentar ahora envia rimagenes, tanto po qpsk y gmsk
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 3,0,1,2
    name: '"Espectro de la señal a transmitir"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    label1: I
    label2: Q
    name: '"Envolvente compleja de infromacion modulada "'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,1
    name: '"Bits de la fuente"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: satellites_hdlc_framer_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '14'
    preamble_bytes: '100'
  states: {}
- name: satellites_nrzi_encode_0_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: soapy_hackrf_sink_1
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: gain
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mensaje
  states: {state: disabled}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: mensaje
  states: {}
- name: virtual_sink_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: bits_tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mensaje
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mensaje
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: bits_tx
  states: {state: disabled}

connections:
- [analog_random_source_x_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_message_strobe_0_0, strobe, epy_block_0_0, msg_in]
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_1, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle2_0, '0', osmosdr_sink_0, '0']
- [blocks_throttle2_0, '0', osmosdr_sink_1, '0']
- [blocks_throttle2_0, '0', uhd_usrp_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_scrambler_bb_0_0, '0']
- [digital_gfsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_time_sink_x_0, '0']
- [digital_scrambler_bb_0, '0', satellites_nrzi_encode_0_0, '0']
- [digital_scrambler_bb_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [epy_block_0, msg_out, satellites_hdlc_framer_0_0, in]
- [epy_block_0_0, msg_out, satellites_hdlc_framer_0_0, in]
- [pdu_pdu_to_tagged_stream_0_0, '0', digital_scrambler_bb_0, '0']
- [qtgui_edit_box_msg_0_0, msg, blocks_message_strobe_0_0, set_msg]
- [satellites_hdlc_framer_0_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [satellites_nrzi_encode_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [satellites_nrzi_encode_0_0, '0', virtual_sink_0_0_0_0_0_0, '0']
- [virtual_source_0, '0', digital_gfsk_mod_0, '0']
- [virtual_source_0, '0', digital_gmsk_mod_0, '0']
- [virtual_source_1, '0', digital_gmsk_mod_0, '0']
- [virtual_source_1_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
